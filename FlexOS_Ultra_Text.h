// #############################################################
// ##  FLEX OS ULTRA  ·  TIPOGRAFIA BASE, RELOJ VECTORIAL Y TRIANGULOS
// ##  ----------------------------------------------------------
// ##  La API publica de texto (drawText / drawTextC / drawTextR / textW),
// ##  los acentos, el reloj vectorial y las primitivas de triangulo.
// ##
// ##  COMO ENCAJA ESTE ARCHIVO
// ##  ----------------------------------------------------------
// ##  Es una PARTE del sketch FlexOS_Ultra.ino, no una unidad de
// ##  traduccion independiente. FlexOS_Ultra.ino lo incluye en el
// ##  orden que fija la cadena de cabeceras (cada modulo incluye al
// ##  anterior), asi que todo el sistema sigue compilandose como UN
// ##  SOLO archivo, exactamente igual que antes de separarlo.
// ##
// ##  Consecuencias practicas, y son las que mantienen esto seguro:
// ##    · Las variables globales se DEFINEN una sola vez, aqui, en el
// ##      modulo al que pertenecen. No hace falta `extern` ni existe
// ##      el riesgo de una definicion duplicada en el enlazado.
// ##    · El ORDEN de definicion es el mismo que tenia el .ino: una
// ##      funcion `static` solo se puede llamar despues de definirse,
// ##      y esa relacion se conserva modulo a modulo.
// ##    · La cadena de includes es LINEAL (Types -> ... -> Recovery),
// ##      asi que no hay dependencias circulares posibles.
// ##    · No lo incluyas por tu cuenta desde otro sitio: el punto de
// ##      entrada del sistema es siempre FlexOS_Ultra.ino.
// #############################################################
#pragma once
#include "FlexOS_Ultra_Theme.h"   // eslabon anterior de la cadena

// #############################################################
// ##  TIPOGRAFIA + RELOJ VECTORIAL + TRIANGULOS  (original)
// #############################################################

// Fuente 5x7 (column-major, bit0 = arriba). ASCII 0x20..0x7E.
static const uint8_t FONT5x7[95][5] = {
  {0x00,0x00,0x00,0x00,0x00},{0x00,0x00,0x5F,0x00,0x00},{0x00,0x07,0x00,0x07,0x00},
  {0x14,0x7F,0x14,0x7F,0x14},{0x24,0x2A,0x7F,0x2A,0x12},{0x23,0x13,0x08,0x64,0x62},
  {0x36,0x49,0x55,0x22,0x50},{0x00,0x05,0x03,0x00,0x00},{0x00,0x1C,0x22,0x41,0x00},
  {0x00,0x41,0x22,0x1C,0x00},{0x14,0x08,0x3E,0x08,0x14},{0x08,0x08,0x3E,0x08,0x08},
  {0x00,0x50,0x30,0x00,0x00},{0x08,0x08,0x08,0x08,0x08},{0x00,0x60,0x60,0x00,0x00},
  {0x20,0x10,0x08,0x04,0x02},{0x3E,0x51,0x49,0x45,0x3E},{0x00,0x42,0x7F,0x40,0x00},
  {0x42,0x61,0x51,0x49,0x46},{0x21,0x41,0x45,0x4B,0x31},{0x18,0x14,0x12,0x7F,0x10},
  {0x27,0x45,0x45,0x45,0x39},{0x3C,0x4A,0x49,0x49,0x30},{0x01,0x71,0x09,0x05,0x03},
  {0x36,0x49,0x49,0x49,0x36},{0x06,0x49,0x49,0x29,0x1E},{0x00,0x36,0x36,0x00,0x00},
  {0x00,0x56,0x36,0x00,0x00},{0x08,0x14,0x22,0x41,0x00},{0x14,0x14,0x14,0x14,0x14},
  {0x00,0x41,0x22,0x14,0x08},{0x02,0x01,0x51,0x09,0x06},{0x32,0x49,0x79,0x41,0x3E},
  {0x7E,0x11,0x11,0x11,0x7E},{0x7F,0x49,0x49,0x49,0x36},{0x3E,0x41,0x41,0x41,0x22},
  {0x7F,0x41,0x41,0x22,0x1C},{0x7F,0x49,0x49,0x49,0x41},{0x7F,0x09,0x09,0x09,0x01},
  {0x3E,0x41,0x49,0x49,0x7A},{0x7F,0x08,0x08,0x08,0x7F},{0x00,0x41,0x7F,0x41,0x00},
  {0x20,0x40,0x41,0x3F,0x01},{0x7F,0x08,0x14,0x22,0x41},{0x7F,0x40,0x40,0x40,0x40},
  {0x7F,0x02,0x0C,0x02,0x7F},{0x7F,0x04,0x08,0x10,0x7F},{0x3E,0x41,0x41,0x41,0x3E},
  {0x7F,0x09,0x09,0x09,0x06},{0x3E,0x41,0x51,0x21,0x5E},{0x7F,0x09,0x19,0x29,0x46},
  {0x46,0x49,0x49,0x49,0x31},{0x01,0x01,0x7F,0x01,0x01},{0x3F,0x40,0x40,0x40,0x3F},
  {0x1F,0x20,0x40,0x20,0x1F},{0x3F,0x40,0x38,0x40,0x3F},{0x63,0x14,0x08,0x14,0x63},
  {0x07,0x08,0x70,0x08,0x07},{0x61,0x51,0x49,0x45,0x43},{0x00,0x7F,0x41,0x41,0x00},
  {0x02,0x04,0x08,0x10,0x20},{0x00,0x41,0x41,0x7F,0x00},{0x04,0x02,0x01,0x02,0x04},
  {0x40,0x40,0x40,0x40,0x40},{0x00,0x01,0x02,0x04,0x00},{0x20,0x54,0x54,0x54,0x78},
  {0x7F,0x48,0x44,0x44,0x38},{0x38,0x44,0x44,0x44,0x20},{0x38,0x44,0x44,0x48,0x7F},
  {0x38,0x54,0x54,0x54,0x18},{0x08,0x7E,0x09,0x01,0x02},{0x0C,0x52,0x52,0x52,0x3E},
  {0x7F,0x08,0x04,0x04,0x78},{0x00,0x44,0x7D,0x40,0x00},{0x20,0x40,0x44,0x3D,0x00},
  {0x7F,0x10,0x28,0x44,0x00},{0x00,0x41,0x7F,0x40,0x00},{0x7C,0x04,0x18,0x04,0x78},
  {0x7C,0x08,0x04,0x04,0x78},{0x38,0x44,0x44,0x44,0x38},{0x7C,0x14,0x14,0x14,0x08},
  {0x08,0x14,0x14,0x18,0x7C},{0x7C,0x08,0x04,0x04,0x08},{0x48,0x54,0x54,0x54,0x20},
  {0x04,0x3F,0x44,0x40,0x20},{0x3C,0x40,0x40,0x20,0x7C},{0x1C,0x20,0x40,0x20,0x1C},
  {0x3C,0x40,0x30,0x40,0x3C},{0x44,0x28,0x10,0x28,0x44},{0x0C,0x50,0x50,0x50,0x3C},
  {0x44,0x64,0x54,0x4C,0x44},{0x00,0x08,0x36,0x41,0x00},{0x00,0x00,0x7F,0x00,0x00},
  {0x00,0x41,0x36,0x08,0x00},{0x08,0x04,0x08,0x10,0x08}
};
// Glifos extra: ¿ (invertido) y ¡ (invertido)
static const uint8_t GLYPH_INVQ[5]    = {0x30,0x48,0x45,0x40,0x20};
static const uint8_t GLYPH_INVEXCL[5] = {0x00,0x00,0x7D,0x00,0x00};
// PUNTO MEDIO (U+00B7). Faltaba: mapCP lo mandaba a '?' y por eso los
// separadores de las etiquetas pequenas -- "Notas · Pausada · 180 KB" -- salian
// como interrogaciones en la placa. La fuente vectorial (tamanos >= 2) SI lo
// tenia, asi que el fallo solo se veia en el texto de tamano 1: exactamente lo
// que mostraba la captura de Recientes.
static const uint8_t GLYPH_MIDDOT[5] = {0x00,0x08,0x08,0x08,0x00};

// Tipos de acento (se dibujan sobre/bajo el glifo base)
enum { ACC_NONE=0, ACC_ACUTE, ACC_GRAVE, ACC_TILDE, ACC_DIAER, ACC_CIRC, ACC_CED };

// Mapea un codepoint Unicode a (glifo base, acento). base 1=¿, 2=¡.
static void mapCP(uint32_t cp, uint8_t &base, uint8_t &acc){
  acc = ACC_NONE;
  if(cp < 0x80){ base = (cp >= 0x20 && cp <= 0x7E) ? (uint8_t)cp : '?'; return; }
  switch(cp){
    case 0xE1: base='a'; acc=ACC_ACUTE; return;   case 0xE9: base='e'; acc=ACC_ACUTE; return;
    case 0xED: base='i'; acc=ACC_ACUTE; return;   case 0xF3: base='o'; acc=ACC_ACUTE; return;
    case 0xFA: base='u'; acc=ACC_ACUTE; return;   case 0xFC: base='u'; acc=ACC_DIAER; return;
    case 0xF1: base='n'; acc=ACC_TILDE; return;
    case 0xC1: base='A'; acc=ACC_ACUTE; return;   case 0xC9: base='E'; acc=ACC_ACUTE; return;
    case 0xCD: base='I'; acc=ACC_ACUTE; return;   case 0xD3: base='O'; acc=ACC_ACUTE; return;
    case 0xDA: base='U'; acc=ACC_ACUTE; return;   case 0xD1: base='N'; acc=ACC_TILDE; return;
    case 0xDC: base='U'; acc=ACC_DIAER; return;
    case 0xE0: base='a'; acc=ACC_GRAVE; return;   case 0xE8: base='e'; acc=ACC_GRAVE; return;
    case 0xEC: base='i'; acc=ACC_GRAVE; return;   case 0xF2: base='o'; acc=ACC_GRAVE; return;
    case 0xF9: base='u'; acc=ACC_GRAVE; return;
    case 0xE2: base='a'; acc=ACC_CIRC; return;    case 0xEA: base='e'; acc=ACC_CIRC; return;
    case 0xEE: base='i'; acc=ACC_CIRC; return;    case 0xF4: base='o'; acc=ACC_CIRC; return;
    case 0xFB: base='u'; acc=ACC_CIRC; return;
    case 0xE3: base='a'; acc=ACC_TILDE; return;   case 0xF5: base='o'; acc=ACC_TILDE; return;
    case 0xE7: base='c'; acc=ACC_CED; return;     case 0xC7: base='C'; acc=ACC_CED; return;
    case 0xBF: base=1; return;                    case 0xA1: base=2; return;
    case 0xB7: base=3; return;                    // punto medio: separador de etiquetas
    default:   base='?'; return;
  }
}

static void drawGlyphRaw(int x, int y, uint8_t base, int s, uint16_t col){
  const uint8_t* g;
  if(base == 1) g = GLYPH_INVQ;
  else if(base == 2) g = GLYPH_INVEXCL;
  else if(base == 3) g = GLYPH_MIDDOT;
  else { int idx = (int)base - 0x20; if(idx < 0 || idx > 94) return; g = FONT5x7[idx]; }
  for(int c = 0; c < 5; c++){
    uint8_t bits = g[c];
    for(int r = 0; r < 7; r++){
      if(bits & (1 << r)){
        if(s == 1) px(x + c, y + r, col);
        else fillRect(x + c * s, y + r * s, s, s, col);
      }
    }
  }
}
static void drawAccent(int x, int y, int s, uint8_t acc, uint16_t col){
  float cx = x + 2.5f * s;
  float r = s * 0.55f; if(r < 1.0f) r = 1.0f;
  switch(acc){
    case ACC_ACUTE: strokeSegAA(cx - s, y - s, cx + s, y - 3 * s, r, col); break;
    case ACC_GRAVE: strokeSegAA(cx - s, y - 3 * s, cx + s, y - s, r, col); break;
    case ACC_CIRC:  strokeSegAA(cx - 1.6f * s, y - s, cx, y - 3 * s, r, col);
                    strokeSegAA(cx, y - 3 * s, cx + 1.6f * s, y - s, r, col); break;
    case ACC_TILDE: strokeSegAA(cx - 2 * s, y - 2 * s, cx - 0.4f * s, y - 2.9f * s, r, col);
                    strokeSegAA(cx - 0.4f * s, y - 2.9f * s, cx + 0.6f * s, y - 1.9f * s, r, col);
                    strokeSegAA(cx + 0.6f * s, y - 1.9f * s, cx + 2 * s, y - 2.7f * s, r, col); break;
    case ACC_DIAER: fillCircleAA(cx - s, y - 2 * s, r, col);
                    fillCircleAA(cx + s, y - 2 * s, r, col); break;
    case ACC_CED:   strokeSegAA(cx, y + 7 * s - s, cx - 1.2f * s, y + 7 * s + 0.6f * s, r, col); break;
  }
}

// Glifo del cuerpo con SUPERSAMPLING (3x3) -> bordes suaves.
// A tamano 1 (etiquetas diminutas) se dibuja nitido para no emborronar.
static void drawGlyphSmooth(int x, int y, uint8_t base, int s, uint16_t col, uint8_t alpha){
  const uint8_t* g;
  if(base == 1) g = GLYPH_INVQ;
  else if(base == 2) g = GLYPH_INVEXCL;
  else if(base == 3) g = GLYPH_MIDDOT;
  else { int idx = (int)base - 0x20; if(idx < 0 || idx > 94) return; g = FONT5x7[idx]; }
  if(s <= 1){
    for(int c = 0; c < 5; c++){ uint8_t bits = g[c];
      for(int r = 0; r < 7; r++) if(bits & (1 << r)) pxA(x + c, y + r, col, alpha); }
    return;
  }
  const int SS = 3;
  int W = 5 * s, H = 7 * s;
  for(int ty = 0; ty < H; ty++){
    for(int tx = 0; tx < W; tx++){
      int cov = 0;
      for(int sy = 0; sy < SS; sy++) for(int sx = 0; sx < SS; sx++){
        int ix = (int)((tx + (sx + 0.5f) / SS) / s);
        int iy = (int)((ty + (sy + 0.5f) / SS) / s);
        if(ix >= 0 && ix < 5 && iy >= 0 && iy < 7 && (g[ix] & (1 << iy))) cov++;
      }
      if(cov) pxA(x + tx, y + ty, col, (uint8_t)((cov * alpha) / (SS * SS)));
    }
  }
}

// Ancho de texto en px (para centrar). Cada glifo avanza 6*s.
